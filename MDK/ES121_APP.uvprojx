# Keil uVision project ES121_APP.uvprojx, settings and files
target STM32F103T8 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F103T8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.2.0
  cpu: IRAM(0x20000000,0x5000) IROM(0x08000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: ES121 +hex
  c flags: Optim=4 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER, STM32F10X_MD
  c include: ..\Libraries\STM32_USB-FS-Device_Driver\inc;..\Libraries\MSD\Inc;..\Libraries\CMSIS\Include;..\Libraries\Peripherals\inc;..\SRC
  library: MicroLIB
  memory RVCT4: ROM 0x8004000 size 0x8000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group MSD
    ../Libraries/MSD/Src/: USB_bot.c USB_desc.c USB_istr.c USB_prop.c USB_pwr.c USB_scsi.c
  group STM32_USB-FS-Device_Driver
    ../Libraries/STM32_USB-FS-Device_Driver/src/: usb_core.c usb_init.c usb_int.c usb_mem.c usb_regs.c usb_sil.c
  group Peripherals
    ../Libraries/Peripherals/src/: misc.c stm32f10x_adc.c stm32f10x_dma.c stm32f10x_flash.c stm32f10x_gpio.c stm32f10x_iwdg.c stm32f10x_rcc.c stm32f10x_tim.c stm32f10x_usart.c
  group SRC
    ../SRC/: Disk.c font.c hardware.c iic.c L3G4200D.c main.c oled.c stm32f10x_it.c system_stm32f10x.c UI.c xprintf.c startup_stm32f10x_md.s
